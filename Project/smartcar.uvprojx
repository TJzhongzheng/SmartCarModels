# Keil uVision project smartcar.uvprojx, settings and files
target smartcar (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: smart_car +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: MK60D10
  c misc: --c99
  c include: ..\Libraries\Devices\Inc;..\Libraries\Drivers\Inc;..\Libraries\Startup\CoreSupport;..\Libraries\Startup\DeviceSupport\MDK-ARM;.\Inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Startup
    ../Libraries/Startup/DeviceSupport/: system_MK60D10.c
    ../Libraries/Startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group User
    ./Src/: cam_init.c control.c img_processing.c main.c
  group Drivers
    ../Libraries/Drivers/Src/: cmt.c common.c dma.c ftm.c gpio.c io2iic.c pit.c spi.c systick.c uart.c wdog.c
  group Devices
    ../Libraries/Devices/Src/: lcd.c nrf24l01.c ov7725.c
